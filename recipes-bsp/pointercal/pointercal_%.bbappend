# Append path for RZA1 layer to include bsp pointercal
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
