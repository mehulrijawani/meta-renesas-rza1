require qtgame-common.inc

inherit qt4x11

RCONFLICTS_${PN} = "qtgame-e"
